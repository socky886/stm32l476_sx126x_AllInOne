<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32l476_sx126x.ewp</path>
  </project>
  <batchBuild />
</workspace>
